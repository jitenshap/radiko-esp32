## components/radiko-esp32/Kconfig.projbuild
```kconfig
menu "Radiko Configuration"

config AUTH_KEY
    string "auth key"
	default "MyAUTHKEY"
	help
		Input the auth key(Required)

endmenu
```
